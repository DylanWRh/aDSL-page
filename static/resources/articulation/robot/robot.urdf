Commit message: 1

File: static/resources/articulation/robot/robot.urdf (robot description, URDF)
Before this commit: robot robot, 10 links, 9 joints
Joints:
- joint forearm_1: limit lower=0 upper=2.094395102 -> lower=-2.094395102 upper=0
